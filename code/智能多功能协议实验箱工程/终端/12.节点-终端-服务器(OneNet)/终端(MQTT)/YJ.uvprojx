# Keil uVision project YJ.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,debug
  c include: .\USER;.\USER\LCD;.\USER\ADC;.\USER\FLASH;.\USER\SPI;.\USER\SD;.\USER\jpglib\app;.\USER\jpglib\src;.\USER\FatFs\App;.\USER\FatFs\Fatfs_src;.\USER\LORA;.\USER\Zigbee;.\USER\YJ;.\USER\ESP8266;.\USER\HMAC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c led.c delay.c key.c smg.c usart.c wlan_user.c
  group LCD
    ./USER/LCD/: lcd.c font.c
  group SPI
    ./USER/SPI/: spi.c
  group ADC
    ./USER/ADC/: adc.c
  group FLASH
    ./USER/FLASH/: W25Q64.c
  group SD
    ./USER/SD/: SD_Config.c SD_Driver.c
  group jpglib
    ./USER/jpglib/app/: jpg_app.c
    ./USER/jpglib/src/: tjpgd.c
  group FatFs
    ./USER/FatFs/App/: fatfs_app.c
    ./USER/FatFs/Fatfs_src/: ff.c diskio.c ffunicode.c mycc936.c
  group LORA
    ./USER/LORA/: lora.c
  group Zigbee
    ./USER/Zigbee/: Zigbee.c
  group YJ
    ./USER/YJ/: yj.c
  group ESP8266
    ./USER/ESP8266/: esp8266.c mqtt.c
  group HMAC
    ./USER/HMAC/: utils_hmac.c utils_md5.c utils_sha1.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:FSMC 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
