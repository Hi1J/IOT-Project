# Keil uVision project rtt_gd103.uvprojx, settings and files
target rtt_gd103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103RE GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtt_gd103
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F10X_HD,
  c include: ./application;./drivers;./package/LedBlink
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ./application/: main.c app.c uart.c zigbee_a72.c uart.h Light_Sensor.c people_scanf.c
  group drivers
    ./drivers/: board.h drv_uart.c drv_pin.c drv_gpio.c drv_iic.c drv_people.c drv_pwm.c drv_a72.c
  group package
    ./package/LedBlink/: ledblink.c
software components: CMSIS:CORE 5.5.0, Device:GD32F10x_StdPeripherals:ADC 2.0.2, Device:GD32F10x_StdPeripherals:BKP 2.0.2, Device:GD32F10x_StdPeripherals:CAN 2.0.2, Device:GD32F10x_StdPeripherals:CRC 2.0.2, Device:GD32F10x_StdPeripherals:DAC 2.0.2, Device:GD32F10x_StdPeripherals:DBG 2.0.2, Device:GD32F10x_StdPeripherals:DMA 2.0.2, Device:GD32F10x_StdPeripherals:ENET 2.0.2, Device:GD32F10x_StdPeripherals:EXMC 2.0.2, Device:GD32F10x_StdPeripherals:EXTI 2.0.2, Device:GD32F10x_StdPeripherals:FMC 2.0.2, Device:GD32F10x_StdPeripherals:FWDGT 2.0.2, Device:GD32F10x_StdPeripherals:GPIO 2.0.2, Device:GD32F10x_StdPeripherals:I2C 2.0.2, Device:GD32F10x_StdPeripherals:MISC 2.0.2, Device:GD32F10x_StdPeripherals:PMU 2.0.2, Device:GD32F10x_StdPeripherals:RCU 2.0.2, Device:GD32F10x_StdPeripherals:RTC 2.0.2, Device:GD32F10x_StdPeripherals:SDIO 2.0.2, Device:GD32F10x_StdPeripherals:SPI_I2S 2.0.2, Device:GD32F10x_StdPeripherals:TIMER 2.0.2, Device:GD32F10x_StdPeripherals:USART 2.0.2, Device:GD32F10x_libopt 2.0.2, Device:Startup 2.0.2, RTOS:device 3.1.5, RTOS:kernel 3.1.5, RTOS:shell 3.1.5
